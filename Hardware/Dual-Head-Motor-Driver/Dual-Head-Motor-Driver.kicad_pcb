# Repository baoqi-zhong/Awesome-SMT-Machine

File README.md:

# :fire: Awesome :fire: SMT Machine

[中文文档](./README_CN.md)

Contributors:
<p float="left">

</p>

**Awesome SMT Machine** is an open-source Pick and Place machine project that originated from an embedded system course. The project features a fully self-developed software, hardware, and mechanical design.

It utilizes a **CoreXY** architecture for 4-DOF placement and integrates a custom **FOC (Field Oriented Control) closed-loop stepper motor driver** for high-precision and high-response positioning. The system includes a 4.2-inch color touch screen for real-time status monitoring and uses Python-based host software for coordinate file parsing and fully automatic placement.

**Key Features**:
- **Core-XY Structure**: High precision and high-speed motion.
- **FOC Stepper Driver**: Heat-free, highly efficient, and silent operation.
- **Interactive UI**: 4.2-inch color touch screen.
- **Host Software**: Python-based control for automated workflow.

# Hardware

The hardware consists of 4-layer PCBs designed using **KiCad**.

**Directory Structure**:
```
./Hardware/
    Main-Control-Board          Main control motherboard
    Stepper-Motor-FOC-Driver    FOC driver for Nema-17 stepper motors
    LCD-Board                   TFT display interface board
    Dual-Head-Motor-Driver      (Ongoing) Controller for the dual-head placement module
```

## Main Control Board

Powered by an **STM32G431CBU6** MCU, SC8815 battery management system, and ACM8625S I2S audio amplifier.  
For details, see [Main Control Board Schematic](./Hardware/Main-Control-Board/Main-Control-Board-Schematic.pdf).

**Features**:
- **UART Interface**: Communication with the Python host software.
- **6S Battery Charger**: Supports fast charging and wide input voltage range.
- **Audio System**: Integrated amplifier and speaker (just for fun! :yum:).
- **CAN Bus**: High reliability and scalability.

## Stepper Motor FOC Driver

Based on **STM32G431CBU6** MCU, DRV8412 gate driver, MA732 magnetic encoder, and WS2812 RGB LEDs.  
For details, see [Stepper Motor FOC Driver Schematic](./Hardware/Stepper-Motor-FOC-Driver/Stepper-Motor-FOC-Driver-Schematic.pdf).

**Features**:
- **Custom FOC Algorithm**: Three-loop control (Torque, Speed, Angle). Implements DQ-axis decoupling, BEMF feedforward, cogging torque compensation, and dead-time compensation.
- **Precision Control**: Real current loop ensures precise torque control.
- **14-Bit Encoder**: High-speed magnetic encoder with automatic calibration and adaptive notch filter (ANF) for low noise.
- **CAN Bus**: Bi-directional communication.

# Software
The embedded software is developed using **STM32CubeMX**, **Makefile**, and **GCC**. The FOC algorithm is implemented with a bare-metal interrupt-driven architecture for maximum performance. The main control board utilizes **FreeRTOS** for multitasking (communication, motion control, battery management, audio playback, etc.).

**Directory Structure**:
```
./Software/
    ClosePnP                        Python/tkinter-based host control software (inspired by OpenPnP)
    Main-Control-Board-Software     STM32 firmware for the main board
    Stepper-Motor-Driver-Software   FOC algorithm source code
    MusicConverter                  Python script to convert .WAV files to C arrays for audio testing
    Dual-Head-Motor-Driver-Software (Ongoing) Firmware for the dual-head motor driver
```

# Mechanical
The original single-head version was designed using **Cinema 4D (C4D)**. The newer dual-head version is designed with **SolidWorks**.

- **Single-head source files**: `./Mechanical/CoreXY.c4d` (or `./Mechanical/CoreXY.stl`).

## KiCad design Hardware/Dual-Head-Motor-Driver/Dual-Head-Motor-Driver.kicad_pcb

Parts:
C1, C25, C26, C27: 100n; C_0603_1608Metric
C2, C3, C10, C11, C14, C15, C17, C18, C21, C32, C34: 100nF; C_0603_1608Metric
C4, C5, C7: 10uF; C_0603_1608Metric
C6, C8: 10nF; C_0603_1608Metric
C9, C12, C13, C16, C20, C33: 10uF; C_1206_3216Metric
C19, C31: 10n; C_0603_1608Metric
C22, C28, C29, C30: 100pF; C_0603_1608Metric
C23, C24: 10uF; C_0805_2012Metric
D1: NUP2105L; SOT-23
D2, D5: K34; D_SMF
D3: SMAJ18A; D_SMA
D4: SMF5A; D_SMF
F2: 8A 1206; Fuse_1206_3216Metric
H1, H2, H3: M2; MountingHole_2.2mm_M2_Pad_Via
J3: Conn; JST_PH_B6B-PH-K_1x06_P2.00mm_Vertical
J4, J5: GPIO; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
J6: GPIO; JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
J7: SWD; Molex_PicoBlade_53047-0410_1x04_P1.25mm_Vertical
L1: 4.7uH; L_Sunlord_SWPA3015S
Q1, Q2: AO3400A; SOT-23
R1: 10k; R_0603_1608Metric
R2: 120R; R_0603_1608Metric
R5: 51K; R_0603_1608Metric
R6, R19: 10K; R_0603_1608Metric
R7, R10, R11, R12, R13, R14: 100m; R_0805_2012Metric
R8, R15, R23: 2K; R_0603_1608Metric
R9, R16, R20, R21, R22, R24: 1K; R_0603_1608Metric
R18: 54.3K; R_0603_1608Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16: M; TestPoint_Pad_2.0x2.0mm
TP17: GND; TestPoint_Pad_2.0x2.0mm
TP18: MicroSW; TestPoint_Pad_2.0x2.0mm
U1: STM32G431CBUx; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U2: TJA1042T-3; SOIC-8_3.9x4.9mm_P1.27mm
U3: RS3236; SOT-23-5
U4, U5, U6: DRV8848; TSSOP-16-1EP_4.4x5mm_P0.65mm
U7: RY8411; SOT-23-6
Y1: 8MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3V3: C3.1, C4.1, C7.1, C25.1, C26.1, C27.1, J7.4, R1.1, R8.2, R15.2, R20.2, R21.2, R22.2, R23.2, U1.1 (VBAT), U1.20 (VREF+), U1.21 (VDDA), U1.23 (VDD), U1.35 (VDD), U1.48 (VDD), U2.5 (VIO), U3.5 (OUT)
+5V: C2.1, C5.1, C12.1, C22.1, C23.1, C24.1, C32.1, C33.1, C34.1, D2.1 (K), D4.1 (A1), D5.1 (K), L1.2, R18.1, TP13.1, TP15.1, U2.3 (VCC), U3.1 (IN), U3.3 (EN)
+18V: C9.1, C10.1, C13.1, C14.1, C16.1, C17.1, C20.1, D3.1 (A1), F2.2, R5.2, U4.12 (VM), U5.12 (VM), U6.12 (VM), U7.4 (EN), U7.5 (IN)
/CAN_H: D1.1 (K), J3.3, R2.1, U2.7 (CANH)
/CAN_L: D1.2 (K), J3.4, R2.2, U2.6 (CANL)
/CAN_RX: U1.33 (PA11), U2.4 (RXD)
/CAN_TX: U1.34 (PA12), U2.1 (TXD)
/GPIO1: J6.1, U1.8 (PA0)
/GPIO2: J5.1, U1.25 (PB12)
/GPIO3: J4.1, U1.4 (PC15)
/M1_AIN1: U1.29 (PC6), U4.16 (AIN1)
/M1_AIN2: U1.30 (PA8), U4.15 (AIN2)
/M1_AOUT1: TP9.1, U4.2 (AOUT1)
/M1_AOUT2: TP10.1, U4.4 (AOUT2)
/M1_BIN1: U1.31 (PA9), U4.9 (BIN1)
/M1_BIN2: U1.32 (PA10), U4.10 (BIN2)
/M1_BOUT1: TP11.1, U4.7 (BOUT1)
/M1_BOUT2: TP12.1, U4.5 (BOUT2)
/M1_IA_SENSE: R7.1, U1.9 (PA1), U4.3 (AISEN)
/M1_IB_SENSE: R10.1, U4.6 (BISEN)
/M1_VREF: R8.1, R9.2, U4.11 (VREF)
/M1_nFAULT: U1.2 (PC13), U4.8 (~FAULT)
/M1_nSLEEP: R20.1, U4.1 (~SLEEP)
/M2_AIN1: U1.38 (PA15), U5.16 (AIN1)
/M2_AIN2: U1.39 (PC10), U5.15 (AIN2)
/M2_AOUT1: TP1.1, U5.2 (AOUT1)
/M2_AOUT2: TP2.1, U5.4 (AOUT2)
/M2_BIN1: U1.40 (PC11), U5.9 (BIN1)
/M2_BIN2: U1.41 (PB3), U5.10 (BIN2)
/M2_BOUT1: TP3.1, U5.7 (BOUT1)
/M2_BOUT2: TP4.1, U5.5 (BOUT2)
/M2_IA_SENSE: R11.1, U1.15 (PA7), U5.3 (AISEN)
/M2_IB_SENSE: R12.1, U5.6 (BISEN)
/M2_VREF: C19.1, R15.1, R16.2, U5.11 (VREF)
/M2_nFAULT: U1.42 (PB4), U5.8 (~FAULT)
/M2_nSLEEP: R21.1, U5.1 (~SLEEP)
/M3_AIN1: U1.44 (PB6), U6.16 (AIN1)
/M3_AIN2: U1.45 (PB7), U6.15 (AIN2)
/M3_AOUT1: TP5.1, U6.2 (AOUT1)
/M3_AOUT2: TP6.1, U6.4 (AOUT2)
/M3_BIN1: U1.47 (PB9), U6.9 (BIN1)
/M3_BIN2: U1.46 (PB8), U6.10 (BIN2)
/M3_BOUT1: TP7.1, U6.7 (BOUT1)
/M3_BOUT2: TP8.1, U6.5 (BOUT2)
/M3_IA_SENSE: R13.1, U1.17 (PB0), U6.3 (AISEN)
/M3_IB_SENSE: R14.1, U6.6 (BISEN)
/M3_VREF: C31.1, R23.1, R24.2, U6.11 (VREF)
/M3_nFAULT: U1.43 (PB5), U6.8 (~FAULT)
/M3_nSLEEP: R22.1, U6.1 (~SLEEP)
/NRST: C1.1, R1.2, U1.7 (PG10)
/OPAMP1_VINM0: C28.2, U1.11 (PA3)
/OPAMP1_VOUT: C28.1, U1.10 (PA2)
/OPAMP2_VINM0: C29.2, U1.13 (PA5)
/OPAMP2_VOUT: C29.1, U1.14 (PA6)
/OPAMP3_VINM0: C30.2, U1.19 (PB2)
/OPAMP3_VOUT: C30.1, U1.18 (PB1)
/OSC_IN: U1.5 (PF0), Y1.1
/OSC_OUT: U1.6 (PF1), Y1.3
/SWCLK: J7.2, U1.37 (PA14)
/SWDIO: J7.1, U1.36 (PA13)
/VALVE_1: Q1.1 (G), U1.26 (PB13)
/VALVE_2: Q2.1 (G), U1.3 (PC14)
/VBUS_SENSE: C8.1, R5.1, R6.2, U1.24 (PB11)
/microSW: TP18.1, U1.12 (PA4)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C23.2, C24.2, C25.2, C26.2, C27.2, C31.2, C32.2, C33.2, C34.2, D1.3 (A), D3.2 (A2), D4.2 (A2), H1.1, H2.1, H3.1, J3.5, J3.6, J3.MP (MountPin), J4.2, J4.MP (MountPin), J5.2, J5.MP (MountPin), J6.2, J6.MP (MountPin), J7.3, Q1.2 (S), Q2.2 (S), R6.1, R7.2, R9.1, R10.2, R11.2, R12.2, R13.2, R14.2, R16.1, R19.2, R24.1, TP17.1, U1.49 (VSS), U2.2 (GND), U2.8 (STB), U3.2 (GND), U4.13 (GND), U4.17 (GND), U5.13 (GND), U5.17 (GND), U6.13 (GND), U6.17 (GND), U7.2 (GND), Y1.2
unnamed: D2.2 (A), Q1.3 (D), TP14.1
unnamed: D5.2 (A), Q2.3 (D), TP16.1
unnamed: F2.1, J3.1, J3.2
unnamed: C6.1, U3.4 (BP)
unnamed: C11.1, U4.14 (VINT)
unnamed: C15.1, U5.14 (VINT)
unnamed: C18.1, U6.14 (VINT)
unnamed: C21.1, U7.1 (BS)
unnamed: C22.2, R18.2, R19.1, U7.3 (FB)
unnamed: C21.2, L1.1, U7.6 (LX)

Notes on the sheet:
需求分析: CAN,微动开关,3个步进电机驱动(两个Rotate一个摇臂电机),预留rotate归零口 RGB 摄像头补光灯 不需要泵 需要两个阀 固定孔位
CAN
Motor
Other
I=VREF/R/6.6
POWER
MCU
Valve

Board: 4 copper layers, 60.0 x 52.0 mm, 98 parts (40 on the bottom side), 75 nets.

## KiCad design Hardware/Main-Control-Board/Main-Control-Board.kicad_pcb

Board: 4 copper layers, 48.0 x 96.0 mm, 188 parts (7 on the bottom side), 130 nets.

Parts:
C1, C2: 1n; C_0603_1608Metric
C3, C4, C9, C12, C28, C41, C42, C47, C49, C50, C51, C55, C56, C57, C59, C60, C61, C62, C65, C68, C72, C73: 100n; C_0603_1608Metric
C5, C6, C11: 22n; C_0603_1608Metric
C7, C8, C10, C53, C54, C70: 1u; C_0603_1608Metric
C13, C18, C23, C31: 470n; C_0603_1608Metric
C14, C15, C16, C17, C19, C20, C21, C22, C26, C27, C32, C34, C35: 10u; C_1206_3216Metric
C24: 220u; Cap_Al_D8xH12mm_Hor_Flip
C25: 220u; Cap_Al_D8xH12mm_Hor
C29, C37, C38: 20p; C_0603_1608Metric
C30, C36: 47u; CP_EIA-7343-15_Kemet-W
C33, C40, C52, C64, C77: 10u; C_0603_1608Metric
C39: 10n; C_0603_1608Metric
C43, C44, C45, C46: 680n; C_1206_3216Metric
C48: 100u; CP_Radial_D6.3mm_P2.50mm
C66, C67, C74, C75, C76: 22u; C_1206_3216Metric
C69: 220n; C_0603_1608Metric
C71: 4u7; C_0603_1608Metric
D1, D2: R; LED_0603_1608Metric
D3, D4, D13: K34; D_SMF
D5, D7: SMAJ5.0A; D_SMA
D9: NUP2105L; SOT-23
D10, D11: SMCJ28A; D_SMC
D12: Power Good; LED_0603_1608Metric
F1: 1812 1.5A; Fuse_1812_4532Metric
F2, F3: Fuse; Fuse_Littelfuse-NANO2-451_453
F4: Polyfuse_Small; Fuse_1206_3216Metric
F5: 1206 1A; Fuse_1206_3216Metric
F6: 1A 1206; Fuse_1206_3216Metric
FB1: 0603; L_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1, J4: XT30-M; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: SWD; Molex_PicoBlade_53261-0471_1x04-1MP_P1.25mm_Horizontal
J5: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_Palconn_UTC16-G
J6, J7, J8: Conn_01x06_MountingPin; JST_PH_B6B-PH-K_1x06_P2.00mm_Vertical
J9, J10, J11: 2812; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J12, J13: Speaker; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J14, J15: 5V; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J16: Micro_SD_Card_Det1; Card XDFP-0090-012
J17: Conn_01x15_MountingPin; TE_1-84952-5_1x15-1MP_P1.0mm_Horizontal
J18, J20: Switch; JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
L1: 4u7; L_TaiTech_TMPC1265_13.5x12.5mm
L2: 6u8; L_Sunlord_MWSA0402S
L3, L4, L6, L7: 10uH 4030; L_Abracon_ASPI-4030S
L5: 1u5; L_Sunlord_MWSA0603S
Q1, Q2, Q3, Q4: BSC035; TDSON-8-1
R1, R2, R5, R6: 0R; R_0603_1608Metric
R3, R4: 2R2; R_0603_1608Metric
R7, R8: 5m; R_1206_3216Metric
R9, R10, R11, R12: 2R; R_0603_1608Metric
R13: 232k; R_0603_1608Metric
R14, R16, R18, R19, R20, R21, R22, R25, R26, R27, R28, R29, R32, R34, R35, R38, R45: 10k; R_0603_1608Metric
R15: 200k; R_0603_1608Metric
R17: NC; R_0603_1608Metric
R23, R37, R54, R55: 330R; R_0603_1608Metric
R24: 54k6; R_0603_1608Metric
R30, R33, R49: 1k; R_0603_1608Metric
R31, R52, R53: 4k7; R_0603_1608Metric
R39, R47, R50: 120R; R_0603_1608Metric
R42, R43: 33R; R_0603_1608Metric
R48: 3R3; R_0603_1608Metric
R51: 1M; R_0603_1608Metric
RN1: 82R; R_Array_Concave_4x0603
SW1, SW3: NRST; SW_SPST_PTS810
U1: SC8815; QFN-32-1EP_4x4mm_P0.4mm_EP2.65x2.65mm
U2: RY8411; SOT-23-6
U3: RS3236; SOT-23-5
U4: CH340N; SOIC-8_3.9x4.9mm_P1.27mm
U5: ACM8625S; TSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.85x6.7mm
U6: STM32G431CBUx; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U7: TJA1042T-3; SOIC-8_3.9x4.9mm_P1.27mm
U8: NB679; QFN-12 2x3mm (NB679)
Y2: 3225 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C9.1, C40.1, C41.1, C42.1, C51.1, C52.1, C56.1, C57.1, C62.1, C64.1, F4.1, FB1.1, J16.4 (VDD), R19.2, R20.2, R21.2, R22.2, R26.1, R27.1, R28.1, R29.1, R30.1, R33.1, R34.2, R35.2, R38.2, R45.2, U3.5 (OUT), U4.5 (VCC), U4.8 (V3), U5.2 (DVDD), U6.1 (VBAT), U6.21 (VDDA), U6.23 (VDD), U6.35 (VDD), U6.48 (VDD), U7.5 (VIO)
+5V: C29.1, C32.1, C33.1, C34.1, C35.1, C61.1, C77.1, D7.1 (A1), D13.1 (K), J17.1, J17.2, L2.2, R24.1, R31.1, U3.1 (IN), U3.3 (EN), U7.3 (VCC)
+5VP: C30.1, C36.1, C73.1, C74.1, C75.1, C76.1, D5.1 (A1), J9.2, J10.2, J11.2, J14.1, J15.1, L5.2, U8.5 (VOUT)
/ACM8625S_ADR: R20.1, U5.3 (ADR/GPIO2), U6.32 (PA10)
/ACM8625S_PDN: R19.1, U5.12 (PDN), U6.29 (PC6)
/BUTTON_0: C60.1, R37.1, U6.2 (PC13)
/CAN_H: D9.2 (K), J6.3, J7.3, J8.3, R39.1, U7.7 (CANH)
/CAN_L: D9.1 (K), J6.4, J7.4, J8.4, R39.2, U7.6 (CANL)
/CAN_RX: R17.1, U6.33 (PA11), U7.4 (RXD)
/CAN_TX: U6.34 (PA12), U7.1 (TXD)
/I2C1_SCL: R28.2, U1.9 (SCL), U6.46 (PB8)
/I2C1_SDA: R27.2, U1.10 (SDA), U6.45 (PB7)
/I2C2_SCL: R21.1, U5.11 (SCL), U6.31 (PA9)
/I2C2_SDA: R22.1, U5.10 (SDA), U6.30 (PA8)
/I2S2_CK: U5.7 (BCLK), U6.26 (PB13)
/I2S2_SD: U5.8 (SDIN), U6.28 (PB15)
/I2S2_WS: U5.6 (FSYNC), U6.25 (PB12)
/MicroSD_DET: J16.9 (DET), U6.44 (PB6)
/NRST: C59.1, R23.1, R29.2, U6.7 (PG10)
/OSC_IN: C37.1, U6.5 (PF0), Y2.3
/OSC_OUT: C38.1, U6.6 (PF1), Y2.1
/PA3: J17.3, U6.11 (PA3)
/PA4: J17.4, U6.12 (PA4)
/PA6: J17.6, U6.14 (PA6)
/PB0: J17.9, U6.17 (PB0)
/PB1: J17.10, U6.18 (PB1)
/PB2: J17.11, U6.19 (PB2)
/PB10: J17.12, U6.22 (PB10)
/PB11: J17.13, U6.24 (PB11)
/PB14: D2.1 (K), U6.27 (PB14)
/PC4: J17.8, U6.16 (PC4)
/PowerDAC_ACM8625S/OUT_L+: C43.1, J13.1, L3.2
/PowerDAC_ACM8625S/OUT_L-: C45.1, J13.2, L4.2
/PowerDAC_ACM8625S/OUT_R+: C46.1, J12.1, L6.2
/PowerDAC_ACM8625S/OUT_R-: C44.1, J12.2, L7.2
/SC8815_PSTOP: U1.8 (PSTOP), U6.47 (PB9)
/SHIELD: C47.2, J5.S1 (SHIELD), R51.2
/SPI1_MOSI: J17.7, U6.15 (PA7)
/SPI1_SCK: J17.5, U6.13 (PA5)
/SPI3_MISO: RN1.6 (R3.2), U6.42 (PB4)
/SPI3_MOSI: RN1.5 (R4.2), U6.43 (PB5)
/SPI3_NSS: RN1.8 (R1.2), U6.38 (PA15)
/SPI3_SCLK: RN1.7 (R2.2), U6.41 (PB3)
/SWCLK: R42.1, U6.37 (PA14)
/SWDIO: R43.1, U6.36 (PA13)
/Switch_0: C55.1, R54.1, U6.3 (PC14)
/Switch_1: C72.1, R55.1, U6.4 (PC15)
/SysPower/BT1: C3.2, U1.30 (BT1)
/SysPower/BT2: C4.1, U1.20 (BT2)
/SysPower/COMP: R18.1, U1.15 (COMP)
/SysPower/DITHER: C12.1, U1.4 (PGATE/DITHER)
/SysPower/FB: R13.2, R14.1, U1.14 (FB)
/SysPower/HD1: R5.2, U1.29 (HD1)
/SysPower/HD2: R6.2, U1.21 (HD2)
/SysPower/INT: R26.2, U1.11 (INT)
/SysPower/LD1: R1.2, U1.27 (LD1)
/SysPower/LD2: R2.2, U1.23 (LD2)
/SysPower/NB679_EN: R31.2, R32.1, U8.11 (EN)
/SysPower/NB679_LDO: C71.1, U8.6 (LDO)
/SysPower/NB679_PG: D12.2 (A), R49.2, U8.3 (PG)
/SysPower/NB679_VCC: C70.1, R49.1, U8.9 (VCC)
/SysPower/SNS1N: C5.2, R10.2, U1.32 (SNS1N)
/SysPower/SNS1P: C5.1, R9.2, U1.1 (SNS1P)
/SysPower/SNS2N: C6.1, R11.2, U1.17 (SNS2N)
/SysPower/SNS2P: C6.2, R12.2, U1.18 (SNS2P)
/SysPower/SW1: C3.1, L1.2, Q1.5 (D), Q3.1 (S), Q3.2 (S), Q3.3 (S), R3.1, U1.28 (SW1)
/SysPower/SW2: C4.2, L1.1, Q2.5 (D), Q4.1 (S), Q4.2 (S), Q4.3 (S), R4.1, U1.22 (SW2)
/SysPower/VBATS: R15.2, R16.1, U1.16 (VBATS)
/SysPower/VCC: C10.1, U1.24 (VCC), U1.25 (VDRV)
/TIM2_CH1: J11.1, U6.8 (PA0)
/TIM2_CH2: J10.1, U6.9 (PA1)
/TIM2_CH3: J9.1, U6.10 (PA2)
/USART3_RX: R45.1, R47.2, U6.40 (PC11)
/USART3_TX: R50.2, U6.39 (PC10)
/USB_DN: J5.A7 (D-), J5.B7 (D-), U4.2 (UD-)
/USB_DP: J5.A6 (D+), J5.B6 (D+), U4.1 (UD+)
/VREF+: C65.1, FB1.2, U6.20 (VREF+)
GND: C1.2, C2.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.1, C15.1, C16.1, C17.1, C19.2, C20.2, C21.2, C22.2, C24.2, C25.2, C26.2, C27.2, C30.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.1, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C59.2, C60.2, C61.2, C62.2, C64.2, C65.2, C66.2, C67.2, C68.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, D1.1 (K), D5.2 (A2), D7.2 (A2), D9.3 (A), D10.2 (A2), D11.2 (A2), D12.1 (K), J1.1, J2.3, J2.MP (MountPin), J4.1, J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J6.5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
unnamed: C1.1, R3.2
unnamed: C2.1, R4.2
unnamed: C11.1, R18.2
unnamed: C69.1, R48.2
unnamed: D1.2 (A), R30.2
unnamed: D2.2 (A), R33.2
unnamed: D3.1 (K), D4.1 (K), F5.1
unnamed: D13.2 (A), F6.2
unnamed: F6.1, J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS)
unnamed: F2.2, J1.2
unnamed: J2.1, R43.2
unnamed: J2.2, R42.2
unnamed: F4.2, J2.4
unnamed: F3.2, J4.2
unnamed: J5.A5 (CC1), R52.1
unnamed: J5.B5 (CC2), R53.1
unnamed: J16.5 (CLK), R38.1, RN1.2 (R2.1)
unnamed: J16.3 (CMD), R35.1, RN1.4 (R4.1)
unnamed: J16.7 (DAT0), RN1.3 (R3.1)
unnamed: J16.2 (DAT3/CD), R34.1, RN1.1 (R1.1)
unnamed: J18.1, R55.2
unnamed: J20.1, R54.2
unnamed: Q1.4 (G), R1.1
unnamed: Q2.4 (G), R2.1
unnamed: Q3.5 (D), R7.2, R10.1
unnamed: Q3.4 (G), R5.1
unnamed: Q4.5 (D), R8.1, R12.1
unnamed: Q4.4 (G), R6.1
unnamed: R23.2, SW3.1
unnamed: R37.2, SW1.1
unnamed: C28.1, U2.1 (BS)
unnamed: C26.1, C27.1, F5.2, U2.4 (EN), U2.5 (IN)
unnamed: C29.2, R24.2, R25.1, U2.3 (FB)
unnamed: C28.2, L2.1, U2.6 (LX)
unnamed: C39.1, U3.4 (BP)
unnamed: R50.1, U4.7 (RXD)
unnamed: R47.1, U4.6 (TXD)
unnamed: C13.1, U5.25 (BST_L+)
unnamed: C18.1, U5.22 (BST_L-)
unnamed: C23.1, U5.18 (BST_R+)
unnamed: C31.1, U5.21 (BST_R-)
unnamed: C13.2, L3.1, U5.26 (OUT_L+)
unnamed: C18.2, L4.1, U5.23 (OUT_L-)
unnamed: C23.2, L6.1, U5.17 (OUT_R+)
unnamed: C31.2, L7.1, U5.20 (OUT_R-)
unnamed: C53.1, U5.13 (VREG_AVDD)
unnamed: C54.1, U5.4 (VREG_DVDD)
unnamed: R48.1, U8.8 (BST)
unnamed: C69.2, L5.1, U8.7 (SW)
unnamed: C66.1, C67.1, C68.1, F1.2, U8.1 (VIN)
VBAT: C8.1, C19.1, C20.1, C21.1, C22.1, C25.1, C48.1, C49.1, C50.1, D4.2 (A), D10.1 (A1), F1.1, F2.1, J6.1, J6.2, J7.1, J7.2, J8.1, J8.2, R8.2, R11.1, R15.1, U1.19 (VBAT), U5.15 (PVDD), U5.16 (PVDD), U5.27 (PVDD), U5.28 (PVDD)
VBUS: C7.1, C14.2, C15.2, C16.2, C17.2, C24.1, D3.2 (A), D11.1 (A1), F3.1, R7.1, R9.1, R13.1, U1.31 (VBUS)

Notices in the files:
README.md:
MIT License
